.option TEMP=27
